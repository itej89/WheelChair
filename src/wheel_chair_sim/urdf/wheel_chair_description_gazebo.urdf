Commit message: made footprint modifications to sim model

File: src/wheel_chair_sim/urdf/wheel_chair_description_gazebo.urdf (robot description, URDF)
Before this commit: robot sam_bot, 7 links, 6 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.12 rpy=0 0 0 -> xyz=0 0 0.22 rpy=0 0 0
